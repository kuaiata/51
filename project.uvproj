# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: key.c key.h delay.c delay.h main.c oled.c oled.h menu.c menu.h data.c data.h eeprom.c eeprom.h I2C.h I2C.c menudisplay.c menudisplay.h
